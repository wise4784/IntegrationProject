SRC_URI += "file://user_2019-06-28-22-02-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


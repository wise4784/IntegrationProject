SRC_URI += "file://user_2019-05-31-17-11-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


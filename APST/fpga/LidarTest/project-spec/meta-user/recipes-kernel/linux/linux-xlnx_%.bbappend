SRC_URI += "file://user_2019-06-13-00-41-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


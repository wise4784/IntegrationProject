SRC_URI += "file://user_2019-06-28-14-49-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


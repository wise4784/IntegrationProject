SRC_URI += "file://user_2019-06-28-17-08-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


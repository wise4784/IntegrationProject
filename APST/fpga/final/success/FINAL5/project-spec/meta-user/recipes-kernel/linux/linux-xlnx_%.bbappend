SRC_URI += "file://user_2019-06-29-00-34-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


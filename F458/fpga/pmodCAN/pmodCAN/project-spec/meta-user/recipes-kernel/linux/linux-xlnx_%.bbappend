SRC_URI += "file://user_2019-04-22-10-58-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


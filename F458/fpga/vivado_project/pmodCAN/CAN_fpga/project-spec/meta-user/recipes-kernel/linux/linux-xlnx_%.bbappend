SRC_URI += "file://user_2019-06-03-10-21-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


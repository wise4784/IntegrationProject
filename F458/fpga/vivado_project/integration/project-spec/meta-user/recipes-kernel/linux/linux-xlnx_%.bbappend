SRC_URI += "file://user_2019-06-18-14-11-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"


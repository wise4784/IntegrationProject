SRC_URI += "file://user_2019-06-14-11-05-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

